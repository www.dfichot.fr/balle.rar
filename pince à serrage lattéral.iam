# Autodesk Inventor assembly: pince à serrage lattéral
## iProperties
Created: 2011-09
Part Number: pince à serrage lattéral
Document SubType Name: Assembly
Designer: Dominique
Author: Dominique
